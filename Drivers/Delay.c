/*****************************************************************
**                   大连理工大学 创新创业学院
**                       物联网应用工坊
**---------------------------------------------------------------
** 项目名称：   WTZP1.0-BlueBerry
** 日    期：   2018-07-08
** 作    者：   温武军
**---------------------------------------------------------------
** 文 件 名：   Delay.c
** 文件说明：   延时程序汇总(晶振24Mhz)
*****************************************************************/

/*---------------------INCLUDES----------------------*/
#include "Delay.h"

/*---------------------VARIABLES---------------------*/


/*---------------------FUNCTIONS---------------------*/
/***********************************************************************
** 函 数 名： delay10ms(void)
** 函数说明： 延迟10ms，与晶振有关,此处24Mhz
**---------------------------------------------------------------------
** 输入参数： 无
** 返回参数： 无
***********************************************************************/
void delay10ms(void)   //误差 -0.041666666667us
{
    unsigned char a,b,c;
    for(c=134;c>0;c--)
        for(b=12;b>0;b--)
            for(a=73;a>0;a--);
}
/***********************************************************************
** 函 数 名： delay1us(unsigned int b)
** 函数说明： 延时程序-延时1us,该函数时间与晶振频率有关，此处为24Mhz,不精准
**---------------------------------------------------------------------
** 输入参数： uint32
** 返回参数： 无
***********************************************************************/
void delay1us(unsigned int b)
{
   while (b--)
   {
       _nop_();_nop_();_nop_();_nop_();_nop_(); _nop_();_nop_();_nop_();_nop_();_nop_();
	   _nop_();_nop_();_nop_();_nop_();_nop_(); _nop_();_nop_();_nop_();_nop_();_nop_();
	   _nop_();_nop_();_nop_();_nop_();
   }
}
/***********************************************************************
** 函 数 名： delay1s()
** 函数说明： 延时程序-延时1s,该函数时间与晶振频率有关，此处为24Mhz
**---------------------------------------------------------------------
** 输入参数： 无
** 返回参数： 无
***********************************************************************/
void delay1s(void)   //误差 -0.000000000017us
{
    unsigned char a,b,c,n;
    for(c=205;c>0;c--)
        for(b=230;b>0;b--)
            for(a=253;a>0;a--);
    for(n=14;n>0;n--);
    _nop_();  
}
/***********************************************************************
** 函 数 名： Delay5us()
** 函数说明： 延时5微妙
**---------------------------------------------------------------------
** 输入参数： 无
** 返回参数： 无
***********************************************************************/
void Delay5us()
{
  uint8 n = 120;
  
  while (n--);
}

/***********************************************************************
** 函 数 名： delay_ms
** 函数说明： 延时k毫秒
**---------------------------------------------------------------------
** 输入参数： uint16 k
** 返回参数： 无
***********************************************************************/
void delay_ms(uint16 k)	
{						
  uint16 i,j;				
  for(i=0;i<k;i++)
  {			
    for(j=0;j<24000;j++)			
    {
      ;
    }
  }						
}				