# Keil uVision project WTZP1.0.uvproj, settings and files
target WTZP1.0-BlueBerry (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: WTZP1.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Board
    ./Board/: Board.h STC8A8K64S4A12.h
  group Drivers
    ./Drivers/: Drivers.h AD5933.c UrstTest.c I2C.c Time.c Delay.c ADC.c Interrupt.c
  group Modules
    ./Modules/: Modules.h DS18B20.c EC.c LUX.c CO2.c PH.c Wifi.c Control.c AM2301.c LCD.c
  group System
    ./System/: System.h System.c Main.c
