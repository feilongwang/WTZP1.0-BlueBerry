/*****************************************************************
**                   大连理工大学 创新创业学院
**                       物联网应用工坊
**---------------------------------------------------------------
** 项目名称：   WTZP1.0-BlueBerry
** 日    期：   2018-07-10
** 作    者：   迟旭
**---------------------------------------------------------------
** 文 件 名：   ph.c
** 文件说明：   溶液ph测量
*****************************************************************/

/*---------------------INCLUDES----------------------*/
#include "ph.h"

/*---------------------VARIABLES---------------------*/
int16  idata ph_value = 0;
float idata ph_k = -10.422f; //-10.422
float idata ph_b = 28388.7324f; //28388.7324

int16 xdata ph_para_x1; //v2-2.249v 1843 //v2 1842 
int16 xdata ph_para_y1; //ph9.18 9180	 //ph9.18 9180
int16 xdata ph_para_x2; //v1-2.856v 2340 //v1 2341 
int16 xdata ph_para_y2; //ph4.0 4000	 //ph4.0 4000

/*---------------------FUNCTIONS---------------------*/
/***********************************************************************
** 函 数 名： InitPara()
** 函数说明： pH参数初始化
**---------------------------------------------------------------------
** 输入参数： 无
** 返回参数： 无
***********************************************************************/
void InitPara(void)
{
	ph_para_x1 = 1842;
	ph_para_y1 = 9180;
	ph_para_x2 = 2341;
	ph_para_y2 = 4000;

	if(ph_para_x1 != ph_para_x2)
	{
		if(ph_para_y1 > ph_para_y2)
		{
			ph_k = 1.0f*(ph_para_y2-ph_para_y1)/(ph_para_x2-ph_para_x1);		
		}
		else
		{
			ph_k = 1.0f*(ph_para_y1-ph_para_y2)/(ph_para_x1-ph_para_x2);
		}
	
		ph_b = ph_para_y1-ph_k*ph_para_x1;
	}
}
/***********************************************************************
** 函 数 名： GetADFilter()
** 函数说明： 得到的数字量取平均值
**---------------------------------------------------------------------
** 输入参数： uint8
** 返回参数： uint16
***********************************************************************/
uint16 GetADFilter(uint8 n)
{
	uint8 i;
	uint16 j;
	uint32 sum=0;

	for(i=0;i<100;i++)
	{
		sum += GetAD(n);

		for(j=0;j<1000;j++);
	}

	return sum/100;	
}
/***********************************************************************
** 函 数 名： ph()
** 函数说明： 完成AD转换，获得ph数字量
**---------------------------------------------------------------------
** 输入参数： 无
** 返回参数： int16
***********************************************************************/
uint16 ph()
{
  uint16 tmp;
	tmp=GetADFilter(0x05); //P1.5 PH
	ph_value = ph_k*tmp+ph_b;
	return ph_value;
}